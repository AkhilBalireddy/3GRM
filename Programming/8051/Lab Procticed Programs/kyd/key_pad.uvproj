# Keil uVision project key_pad.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: key_pad
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: header.h io_driver.c io_lcd.c delay.c main.c io_timer.c keypad.c

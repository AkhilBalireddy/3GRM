# Keil uVision project aravind.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: aravind
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: emb_c.c a1.c data1.c p33.asm p111.asm parity.asm pasww.asm psw.asm rom.asm shift.asm shiftt.asm stack.asm stackk.asm temp.asm ABC.asm ABCD.asm ASAD.asm delay.asm flash.asm imme.asm JPOI.asm one_ms.asm p1.asm p2.asm P12.asm data_typ.c abc.c

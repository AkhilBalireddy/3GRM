# Keil uVision project asmnt.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: a +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: io_driver_asmnt.c delay_ms.c main_asmnt.c header.h main_2.c io_lcd.c main_3.c
